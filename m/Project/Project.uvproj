# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Hardware\SYSCLK;..\Hardware\GPIOConfig;..\Hardware\Delay;..\Hardware\usart;..\Hardware\I2C;..\Hardware\ADC;..\Hardware\PWM;..\Hardware\EEPROM;..\Hardware\ADC11;..\Hardware\TIM
  group Hardware
    ../Hardware/SYSCLK/: SYSCLK.c
    ../Hardware/GPIOConfig/: GPIOConfig.c
    ../Hardware/Delay/: Delay.c
    ../User/: STC8.h
    ../Hardware/usart/: usart2.c
    ../Hardware/I2C/: I2C.c
    ../Hardware/ADC/: ADC.c
    ../Hardware/PWM/: pwm.c
    ../Hardware/EEPROM/: eeprom.c
    ../Hardware/ADC11/: ADC11.c
    ../Hardware/TIM/: TIM.c
  group User
    ../User/: main.c
